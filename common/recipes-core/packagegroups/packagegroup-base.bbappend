RDEPENDS_packagegroup-base-bluetooth_remove = "bluez4"

RDEPENDS_packagegroup-base-bluetooth_append += "bluez5"